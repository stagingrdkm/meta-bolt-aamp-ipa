SUMMARY = "aamp ipa wsjsonrpc bolt image"
inherit base-bolt-image
IMAGE_INSTALL += "aamp"
#IMAGE_INSTALL += "aamp-ipa-launcher"
