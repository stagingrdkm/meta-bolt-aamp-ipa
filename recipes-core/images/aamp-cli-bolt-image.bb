SUMMARY = "aamp-cli rialto-client bolt image for testing"
inherit base-bolt-image
IMAGE_INSTALL += "aamp"
